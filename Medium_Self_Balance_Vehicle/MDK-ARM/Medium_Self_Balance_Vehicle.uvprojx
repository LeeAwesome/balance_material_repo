# Keil uVision project Medium_Self_Balance_Vehicle.uvprojx, settings and files
target Medium_Self_Balance_Vehicle (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Medium_Self_Balance_Vehicle +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: MEM_UNIT_BYTES,ARM_MATH_CM3,MemUnit_T=uint8_T,USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Medium_Self_Balance_Vehicle/Inc;../../../../../MATLAB/STM32-MAT/STM32/addSrc/inc;..\External_C;..\Medium_Self_Balance_Vehicle\Src;..\Medium_Self_Balance_Vehicle\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../External_C/: delay.c filter.c inv_mpu.c inv_mpu_dmp_motion_driver.c IOI2C.c MPU6050.c printf.c
    ../Src/: main.c gpio.c adc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group MATLAB
    G:/Big_Big/MATLAB/STM32-MAT/STM32/addSrc/src/: getBuffPtr.c
    G:/Big_Big/Simulink/STM32Cube_code/Code/Medium_Self_Balance_Vehicle/Medium_Self_Balance_Vehicle/Src/: Medium_Self_Balance_Vehicle.c Medium_Self_Balance_Vehicle_ADC.c Medium_Self_Balance_Vehicle_TIM.c Medium_Self_Balance_Vehicle_USART.c rtGetInf.c rtGetNaN.c rt_nonfinite.c
software components: CMSIS:CORE 4.3.0
